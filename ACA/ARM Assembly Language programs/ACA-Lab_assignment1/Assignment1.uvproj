# Keil uVision project Assignment1.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Assignment1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: add_32bit_numbers.s add_16bit_numbers.s factorial_with_subroutine.s factorial.s addArray_32bit_numbers.s count_ones_zeros.s length_of_string.s square_root.s find_negative_positive.s hex_to_ascii.s
